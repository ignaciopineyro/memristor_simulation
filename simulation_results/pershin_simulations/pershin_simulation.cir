MEMRISTOR SIMULATION - MODEL MemristorModels.PERSHIN
.include /home/ignaciopineyro/memristor_simulation/models//MemristorModels.PERSHIN
