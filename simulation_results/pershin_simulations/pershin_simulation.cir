* MEMRISTOR CIRCUIT - MODEL pershin.sub

* DEPENDENCIES:
.include /home/ignaciopineyro/memristor_simulation/models/pershin.sub

* COMPONENTS:
V1 vin gnd sin 0 5 1
xmem0 vin n10 l0 memristor
xmem1 vin n01 l1 memristor
xmem2 n01 n11 l2 memristor
xmem3 n01 n02 l3 memristor
xmem4 n02 n12 l4 memristor
xmem5 n02 n03 l5 memristor
xmem6 n03 n13 l6 memristor
xmem7 n03 n04 l7 memristor
xmem8 n04 n14 l8 memristor
xmem9 n04 n05 l9 memristor
xmem10 n05 n15 l10 memristor
xmem11 n05 n06 l11 memristor
xmem12 n06 n16 l12 memristor
xmem13 n06 n07 l13 memristor
xmem14 n07 n17 l14 memristor
xmem15 n07 n08 l15 memristor
xmem16 n08 n18 l16 memristor
xmem17 n08 n09 l17 memristor
xmem18 n09 n19 l18 memristor
xmem19 n09 n010 l19 memristor
xmem20 n010 n110 l20 memristor
xmem21 n010 n011 l21 memristor
xmem22 n011 n111 l22 memristor
xmem23 n011 n012 l23 memristor
xmem24 n012 n112 l24 memristor
xmem25 n012 n013 l25 memristor
xmem26 n013 n113 l26 memristor
xmem27 n013 n014 l27 memristor
xmem28 n014 n114 l28 memristor
xmem29 n014 n015 l29 memristor
xmem30 n015 n115 l30 memristor
xmem31 n10 n20 l31 memristor
xmem32 n10 n11 l32 memristor
xmem33 n11 n21 l33 memristor
xmem34 n11 n12 l34 memristor
xmem35 n12 n22 l35 memristor
xmem36 n12 n13 l36 memristor
xmem37 n13 n23 l37 memristor
xmem38 n13 n14 l38 memristor
xmem39 n14 n24 l39 memristor
xmem40 n14 n15 l40 memristor
xmem41 n15 n25 l41 memristor
xmem42 n15 n16 l42 memristor
xmem43 n16 n26 l43 memristor
xmem44 n16 n17 l44 memristor
xmem45 n17 n27 l45 memristor
xmem46 n17 n18 l46 memristor
xmem47 n18 n28 l47 memristor
xmem48 n18 n19 l48 memristor
xmem49 n19 n29 l49 memristor
xmem50 n19 n110 l50 memristor
xmem51 n110 n210 l51 memristor
xmem52 n110 n111 l52 memristor
xmem53 n111 n211 l53 memristor
xmem54 n111 n112 l54 memristor
xmem55 n112 n212 l55 memristor
xmem56 n112 n113 l56 memristor
xmem57 n113 n213 l57 memristor
xmem58 n113 n114 l58 memristor
xmem59 n114 n214 l59 memristor
xmem60 n114 n115 l60 memristor
xmem61 n115 n215 l61 memristor
xmem62 n20 n30 l62 memristor
xmem63 n20 n21 l63 memristor
xmem64 n21 n31 l64 memristor
xmem65 n21 n22 l65 memristor
xmem66 n22 n32 l66 memristor
xmem67 n22 n23 l67 memristor
xmem68 n23 n33 l68 memristor
xmem69 n23 n24 l69 memristor
xmem70 n24 n34 l70 memristor
xmem71 n24 n25 l71 memristor
xmem72 n25 n35 l72 memristor
xmem73 n25 n26 l73 memristor
xmem74 n26 n36 l74 memristor
xmem75 n26 n27 l75 memristor
xmem76 n27 n37 l76 memristor
xmem77 n27 n28 l77 memristor
xmem78 n28 n38 l78 memristor
xmem79 n28 n29 l79 memristor
xmem80 n29 n39 l80 memristor
xmem81 n29 n210 l81 memristor
xmem82 n210 n310 l82 memristor
xmem83 n210 n211 l83 memristor
xmem84 n211 n311 l84 memristor
xmem85 n211 n212 l85 memristor
xmem86 n212 n312 l86 memristor
xmem87 n212 n213 l87 memristor
xmem88 n213 n313 l88 memristor
xmem89 n213 n214 l89 memristor
xmem90 n214 n314 l90 memristor
xmem91 n214 n215 l91 memristor
xmem92 n215 n315 l92 memristor
xmem93 n30 n40 l93 memristor
xmem94 n30 n31 l94 memristor
xmem95 n31 n41 l95 memristor
xmem96 n31 n32 l96 memristor
xmem97 n32 n42 l97 memristor
xmem98 n32 n33 l98 memristor
xmem99 n33 n43 l99 memristor
xmem100 n33 n34 l100 memristor
xmem101 n34 n44 l101 memristor
xmem102 n34 n35 l102 memristor
xmem103 n35 n45 l103 memristor
xmem104 n35 n36 l104 memristor
xmem105 n36 n46 l105 memristor
xmem106 n36 n37 l106 memristor
xmem107 n37 n47 l107 memristor
xmem108 n37 n38 l108 memristor
xmem109 n38 n48 l109 memristor
xmem110 n38 n39 l110 memristor
xmem111 n39 n49 l111 memristor
xmem112 n39 n310 l112 memristor
xmem113 n310 n410 l113 memristor
xmem114 n310 n311 l114 memristor
xmem115 n311 n411 l115 memristor
xmem116 n311 n312 l116 memristor
xmem117 n312 n412 l117 memristor
xmem118 n312 n313 l118 memristor
xmem119 n313 n413 l119 memristor
xmem120 n313 n314 l120 memristor
xmem121 n314 n414 l121 memristor
xmem122 n314 n315 l122 memristor
xmem123 n315 n415 l123 memristor
xmem124 n40 n50 l124 memristor
xmem125 n40 n41 l125 memristor
xmem126 n41 n51 l126 memristor
xmem127 n41 n42 l127 memristor
xmem128 n42 n52 l128 memristor
xmem129 n42 n43 l129 memristor
xmem130 n43 n53 l130 memristor
xmem131 n43 n44 l131 memristor
xmem132 n44 n54 l132 memristor
xmem133 n44 n45 l133 memristor
xmem134 n45 n55 l134 memristor
xmem135 n45 n46 l135 memristor
xmem136 n46 n56 l136 memristor
xmem137 n46 n47 l137 memristor
xmem138 n47 n57 l138 memristor
xmem139 n47 n48 l139 memristor
xmem140 n48 n58 l140 memristor
xmem141 n48 n49 l141 memristor
xmem142 n49 n59 l142 memristor
xmem143 n49 n410 l143 memristor
xmem144 n410 n510 l144 memristor
xmem145 n410 n411 l145 memristor
xmem146 n411 n511 l146 memristor
xmem147 n411 n412 l147 memristor
xmem148 n412 n512 l148 memristor
xmem149 n412 n413 l149 memristor
xmem150 n413 n513 l150 memristor
xmem151 n413 n414 l151 memristor
xmem152 n414 n514 l152 memristor
xmem153 n414 n415 l153 memristor
xmem154 n415 n515 l154 memristor
xmem155 n50 n60 l155 memristor
xmem156 n50 n51 l156 memristor
xmem157 n51 n61 l157 memristor
xmem158 n51 n52 l158 memristor
xmem159 n52 n62 l159 memristor
xmem160 n52 n53 l160 memristor
xmem161 n53 n63 l161 memristor
xmem162 n53 n54 l162 memristor
xmem163 n54 n64 l163 memristor
xmem164 n54 n55 l164 memristor
xmem165 n55 n65 l165 memristor
xmem166 n55 n56 l166 memristor
xmem167 n56 n66 l167 memristor
xmem168 n56 n57 l168 memristor
xmem169 n57 n67 l169 memristor
xmem170 n57 n58 l170 memristor
xmem171 n58 n68 l171 memristor
xmem172 n58 n59 l172 memristor
xmem173 n59 n69 l173 memristor
xmem174 n59 n510 l174 memristor
xmem175 n510 n610 l175 memristor
xmem176 n510 n511 l176 memristor
xmem177 n511 n611 l177 memristor
xmem178 n511 n512 l178 memristor
xmem179 n512 n612 l179 memristor
xmem180 n512 n513 l180 memristor
xmem181 n513 n613 l181 memristor
xmem182 n513 n514 l182 memristor
xmem183 n514 n614 l183 memristor
xmem184 n514 n515 l184 memristor
xmem185 n515 n615 l185 memristor
xmem186 n60 n70 l186 memristor
xmem187 n60 n61 l187 memristor
xmem188 n61 n71 l188 memristor
xmem189 n61 n62 l189 memristor
xmem190 n62 n72 l190 memristor
xmem191 n62 n63 l191 memristor
xmem192 n63 n73 l192 memristor
xmem193 n63 n64 l193 memristor
xmem194 n64 n74 l194 memristor
xmem195 n64 n65 l195 memristor
xmem196 n65 n75 l196 memristor
xmem197 n65 n66 l197 memristor
xmem198 n66 n76 l198 memristor
xmem199 n66 n67 l199 memristor
xmem200 n67 n77 l200 memristor
xmem201 n67 n68 l201 memristor
xmem202 n68 n78 l202 memristor
xmem203 n68 n69 l203 memristor
xmem204 n69 n79 l204 memristor
xmem205 n69 n610 l205 memristor
xmem206 n610 n710 l206 memristor
xmem207 n610 n611 l207 memristor
xmem208 n611 n711 l208 memristor
xmem209 n611 n612 l209 memristor
xmem210 n612 n712 l210 memristor
xmem211 n612 n613 l211 memristor
xmem212 n613 n713 l212 memristor
xmem213 n613 n614 l213 memristor
xmem214 n614 n714 l214 memristor
xmem215 n614 n615 l215 memristor
xmem216 n615 n715 l216 memristor
xmem217 n70 n80 l217 memristor
xmem218 n70 n71 l218 memristor
xmem219 n71 n81 l219 memristor
xmem220 n71 n72 l220 memristor
xmem221 n72 n82 l221 memristor
xmem222 n72 n73 l222 memristor
xmem223 n73 n83 l223 memristor
xmem224 n73 n74 l224 memristor
xmem225 n74 n84 l225 memristor
xmem226 n74 n75 l226 memristor
xmem227 n75 n85 l227 memristor
xmem228 n75 n76 l228 memristor
xmem229 n76 n86 l229 memristor
xmem230 n76 n77 l230 memristor
xmem231 n77 n87 l231 memristor
xmem232 n77 n78 l232 memristor
xmem233 n78 n88 l233 memristor
xmem234 n78 n79 l234 memristor
xmem235 n79 n89 l235 memristor
xmem236 n79 n710 l236 memristor
xmem237 n710 n810 l237 memristor
xmem238 n710 n711 l238 memristor
xmem239 n711 n811 l239 memristor
xmem240 n711 n712 l240 memristor
xmem241 n712 n812 l241 memristor
xmem242 n712 n713 l242 memristor
xmem243 n713 n813 l243 memristor
xmem244 n713 n714 l244 memristor
xmem245 n714 n814 l245 memristor
xmem246 n714 n715 l246 memristor
xmem247 n715 n815 l247 memristor
xmem248 n80 n90 l248 memristor
xmem249 n80 n81 l249 memristor
xmem250 n81 n91 l250 memristor
xmem251 n81 n82 l251 memristor
xmem252 n82 n92 l252 memristor
xmem253 n82 n83 l253 memristor
xmem254 n83 n93 l254 memristor
xmem255 n83 n84 l255 memristor
xmem256 n84 n94 l256 memristor
xmem257 n84 n85 l257 memristor
xmem258 n85 n95 l258 memristor
xmem259 n85 n86 l259 memristor
xmem260 n86 n96 l260 memristor
xmem261 n86 n87 l261 memristor
xmem262 n87 n97 l262 memristor
xmem263 n87 n88 l263 memristor
xmem264 n88 n98 l264 memristor
xmem265 n88 n89 l265 memristor
xmem266 n89 n99 l266 memristor
xmem267 n89 n810 l267 memristor
xmem268 n810 n910 l268 memristor
xmem269 n810 n811 l269 memristor
xmem270 n811 n911 l270 memristor
xmem271 n811 n812 l271 memristor
xmem272 n812 n912 l272 memristor
xmem273 n812 n813 l273 memristor
xmem274 n813 n913 l274 memristor
xmem275 n813 n814 l275 memristor
xmem276 n814 n914 l276 memristor
xmem277 n814 n815 l277 memristor
xmem278 n815 n915 l278 memristor
xmem279 n90 n100 l279 memristor
xmem280 n90 n91 l280 memristor
xmem281 n91 n101 l281 memristor
xmem282 n91 n92 l282 memristor
xmem283 n92 n102 l283 memristor
xmem284 n92 n93 l284 memristor
xmem285 n93 n103 l285 memristor
xmem286 n93 n94 l286 memristor
xmem287 n94 n104 l287 memristor
xmem288 n94 n95 l288 memristor
xmem289 n95 n105 l289 memristor
xmem290 n95 n96 l290 memristor
xmem291 n96 n106 l291 memristor
xmem292 n96 n97 l292 memristor
xmem293 n97 n107 l293 memristor
xmem294 n97 n98 l294 memristor
xmem295 n98 n108 l295 memristor
xmem296 n98 n99 l296 memristor
xmem297 n99 n109 l297 memristor
xmem298 n99 n910 l298 memristor
xmem299 n910 n1010 l299 memristor
xmem300 n910 n911 l300 memristor
xmem301 n911 n1011 l301 memristor
xmem302 n911 n912 l302 memristor
xmem303 n912 n1012 l303 memristor
xmem304 n912 n913 l304 memristor
xmem305 n913 n1013 l305 memristor
xmem306 n913 n914 l306 memristor
xmem307 n914 n1014 l307 memristor
xmem308 n914 n915 l308 memristor
xmem309 n915 n1015 l309 memristor
xmem310 n100 n110 l310 memristor
xmem311 n100 n101 l311 memristor
xmem312 n101 n111 l312 memristor
xmem313 n101 n102 l313 memristor
xmem314 n102 n112 l314 memristor
xmem315 n102 n103 l315 memristor
xmem316 n103 n113 l316 memristor
xmem317 n103 n104 l317 memristor
xmem318 n104 n114 l318 memristor
xmem319 n104 n105 l319 memristor
xmem320 n105 n115 l320 memristor
xmem321 n105 n106 l321 memristor
xmem322 n106 n116 l322 memristor
xmem323 n106 n107 l323 memristor
xmem324 n107 n117 l324 memristor
xmem325 n107 n108 l325 memristor
xmem326 n108 n118 l326 memristor
xmem327 n108 n109 l327 memristor
xmem328 n109 n119 l328 memristor
xmem329 n109 n1010 l329 memristor
xmem330 n1010 n1110 l330 memristor
xmem331 n1010 n1011 l331 memristor
xmem332 n1011 n1111 l332 memristor
xmem333 n1011 n1012 l333 memristor
xmem334 n1012 n1112 l334 memristor
xmem335 n1012 n1013 l335 memristor
xmem336 n1013 n1113 l336 memristor
xmem337 n1013 n1014 l337 memristor
xmem338 n1014 n1114 l338 memristor
xmem339 n1014 n1015 l339 memristor
xmem340 n1015 n1115 l340 memristor
xmem341 n110 n120 l341 memristor
xmem342 n110 n111 l342 memristor
xmem343 n111 n121 l343 memristor
xmem344 n111 n112 l344 memristor
xmem345 n112 n122 l345 memristor
xmem346 n112 n113 l346 memristor
xmem347 n113 n123 l347 memristor
xmem348 n113 n114 l348 memristor
xmem349 n114 n124 l349 memristor
xmem350 n114 n115 l350 memristor
xmem351 n115 n125 l351 memristor
xmem352 n115 n116 l352 memristor
xmem353 n116 n126 l353 memristor
xmem354 n116 n117 l354 memristor
xmem355 n117 n127 l355 memristor
xmem356 n117 n118 l356 memristor
xmem357 n118 n128 l357 memristor
xmem358 n118 n119 l358 memristor
xmem359 n119 n129 l359 memristor
xmem360 n119 n1110 l360 memristor
xmem361 n1110 n1210 l361 memristor
xmem362 n1110 n1111 l362 memristor
xmem363 n1111 n1211 l363 memristor
xmem364 n1111 n1112 l364 memristor
xmem365 n1112 n1212 l365 memristor
xmem366 n1112 n1113 l366 memristor
xmem367 n1113 n1213 l367 memristor
xmem368 n1113 n1114 l368 memristor
xmem369 n1114 n1214 l369 memristor
xmem370 n1114 n1115 l370 memristor
xmem371 n1115 n1215 l371 memristor
xmem372 n120 n130 l372 memristor
xmem373 n120 n121 l373 memristor
xmem374 n121 n131 l374 memristor
xmem375 n121 n122 l375 memristor
xmem376 n122 n132 l376 memristor
xmem377 n122 n123 l377 memristor
xmem378 n123 n133 l378 memristor
xmem379 n123 n124 l379 memristor
xmem380 n124 n134 l380 memristor
xmem381 n124 n125 l381 memristor
xmem382 n125 n135 l382 memristor
xmem383 n125 n126 l383 memristor
xmem384 n126 n136 l384 memristor
xmem385 n126 n127 l385 memristor
xmem386 n127 n137 l386 memristor
xmem387 n127 n128 l387 memristor
xmem388 n128 n138 l388 memristor
xmem389 n128 n129 l389 memristor
xmem390 n129 n139 l390 memristor
xmem391 n129 n1210 l391 memristor
xmem392 n1210 n1310 l392 memristor
xmem393 n1210 n1211 l393 memristor
xmem394 n1211 n1311 l394 memristor
xmem395 n1211 n1212 l395 memristor
xmem396 n1212 n1312 l396 memristor
xmem397 n1212 n1213 l397 memristor
xmem398 n1213 n1313 l398 memristor
xmem399 n1213 n1214 l399 memristor
xmem400 n1214 n1314 l400 memristor
xmem401 n1214 n1215 l401 memristor
xmem402 n1215 n1315 l402 memristor
xmem403 n130 n140 l403 memristor
xmem404 n130 n131 l404 memristor
xmem405 n131 n141 l405 memristor
xmem406 n131 n132 l406 memristor
xmem407 n132 n142 l407 memristor
xmem408 n132 n133 l408 memristor
xmem409 n133 n143 l409 memristor
xmem410 n133 n134 l410 memristor
xmem411 n134 n144 l411 memristor
xmem412 n134 n135 l412 memristor
xmem413 n135 n145 l413 memristor
xmem414 n135 n136 l414 memristor
xmem415 n136 n146 l415 memristor
xmem416 n136 n137 l416 memristor
xmem417 n137 n147 l417 memristor
xmem418 n137 n138 l418 memristor
xmem419 n138 n148 l419 memristor
xmem420 n138 n139 l420 memristor
xmem421 n139 n149 l421 memristor
xmem422 n139 n1310 l422 memristor
xmem423 n1310 n1410 l423 memristor
xmem424 n1310 n1311 l424 memristor
xmem425 n1311 n1411 l425 memristor
xmem426 n1311 n1312 l426 memristor
xmem427 n1312 n1412 l427 memristor
xmem428 n1312 n1313 l428 memristor
xmem429 n1313 n1413 l429 memristor
xmem430 n1313 n1314 l430 memristor
xmem431 n1314 n1414 l431 memristor
xmem432 n1314 n1315 l432 memristor
xmem433 n1315 n1415 l433 memristor
xmem434 n140 n150 l434 memristor
xmem435 n140 n141 l435 memristor
xmem436 n141 n151 l436 memristor
xmem437 n141 n142 l437 memristor
xmem438 n142 n152 l438 memristor
xmem439 n142 n143 l439 memristor
xmem440 n143 n153 l440 memristor
xmem441 n143 n144 l441 memristor
xmem442 n144 n154 l442 memristor
xmem443 n144 n145 l443 memristor
xmem444 n145 n155 l444 memristor
xmem445 n145 n146 l445 memristor
xmem446 n146 n156 l446 memristor
xmem447 n146 n147 l447 memristor
xmem448 n147 n157 l448 memristor
xmem449 n147 n148 l449 memristor
xmem450 n148 n158 l450 memristor
xmem451 n148 n149 l451 memristor
xmem452 n149 n159 l452 memristor
xmem453 n149 n1410 l453 memristor
xmem454 n1410 n1510 l454 memristor
xmem455 n1410 n1411 l455 memristor
xmem456 n1411 n1511 l456 memristor
xmem457 n1411 n1412 l457 memristor
xmem458 n1412 n1512 l458 memristor
xmem459 n1412 n1413 l459 memristor
xmem460 n1413 n1513 l460 memristor
xmem461 n1413 n1414 l461 memristor
xmem462 n1414 n1514 l462 memristor
xmem463 n1414 n1415 l463 memristor
xmem464 n1415 n1515 l464 memristor
xmem465 n150 n151 l465 memristor
xmem466 n151 n152 l466 memristor
xmem467 n152 n153 l467 memristor
xmem468 n153 n154 l468 memristor
xmem469 n154 n155 l469 memristor
xmem470 n155 n156 l470 memristor
xmem471 n156 n157 l471 memristor
xmem472 n157 n158 l472 memristor
xmem473 n158 n159 l473 memristor
xmem474 n159 n1510 l474 memristor
xmem475 n1510 n1511 l475 memristor
xmem476 n1511 n1512 l476 memristor
xmem477 n1512 n1513 l477 memristor
xmem478 n1513 n1514 l478 memristor
xmem479 n1514 n1515 l479 memristor

* ANALYSIS COMMANDS:
.tran 0.002 2 1e-09  uic

* CONTROL COMMANDS:
.control
run
set wr_vecnames
set wr_singlescale
wrdata /home/ignaciopineyro/memristor_simulation/simulation_results/pershin_simulations/default_network/default_network_simulation.csv vin i(v1) l0
quit

.endc
.end
